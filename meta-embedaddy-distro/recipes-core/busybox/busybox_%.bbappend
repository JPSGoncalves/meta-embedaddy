FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://embdy-busybox.cfg"
