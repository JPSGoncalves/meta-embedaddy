PACKAGECONFIG = " \
    kmod \
    randomseed \
    sysusers \
    link-udev-shared \
    networkd \
    resolved \
    nss-resolve \
    timesyncd \
    zstd \
"
