require u-boot-embdy.inc

# v2026.04
SRCREV = "88dc2788777babfd6322fa655df549a019aa1e69"
DEPENDS += "gnutls-native"
